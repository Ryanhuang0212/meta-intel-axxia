# No GUI suported
PACKAGECONFIG = ""
